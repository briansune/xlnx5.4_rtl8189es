## rtl8189es/Kconfig
```kconfig
config RTL8189ES
	tristate "Realtek 8189F SDIO WiFi"
	depends on USB
	---help---
	  Help message of RTL8189ES
```
